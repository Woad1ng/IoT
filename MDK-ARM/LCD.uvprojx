# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: LCD
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,EXT_Flash_SPI,USE_PWR_LDO_SUPPLY,MYLOG
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../BSP;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x48000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group BSP
    ../BSP/: MyHFile.h LED.c LED.h lcd_rgb.c lcd_rgb.h SDRAM.c SDRAM.h lcd_fonts.h lcd_fonts.c MyTask.c MyTask.h touch_800x480.c touch_800x480.h touch_iic.c touch_iic.h UART.c UART.h Time.c Time.h ADC.c ADC.h GPS.c GPS.h atk_imu_901.c atk_imu_901.h AIR780EX.c AIR780EX.h Angle.c Angle.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group gui
    ../touchgfx/gui/src/about_menu_screen/: about_menupresenter.cpp about_menuview.cpp
    ../touchgfx/gui/src/act_menu_screen/: act_menupresenter.cpp act_menuview.cpp
    ../touchgfx/gui/src/containers/: compass.cpp compass_1.cpp customcontainer1.cpp emergency.cpp triangle.cpp
    ../touchgfx/gui/src/fpv_menu_screen/: fpv_menupresenter.cpp fpv_menuview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/main_menu_screen/: main_menupresenter.cpp main_menuview.cpp
    ../touchgfx/gui/src/map_menu_screen/: map_menupresenter.cpp map_menuview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/sensor_menu_screen/: sensor_menupresenter.cpp sensor_menuview.cpp
    ../touchgfx/gui/src/set_menu_screen/: set_menupresenter.cpp set_menuview.cpp
  group generated
    ../touchgfx/generated/gui_generated/src/about_menu_screen/: about_menuviewbase.cpp
    ../touchgfx/generated/gui_generated/src/act_menu_screen/: act_menuviewbase.cpp
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp compressedfontcache.cpp compressedunmappedfontcache.cpp font_stfangso_ttf_25_4bpp_0.cpp font_stfangso_ttf_25_4bpp_10.cpp font_stfangso_ttf_25_4bpp_11.cpp font_stfangso_ttf_25_4bpp_12.cpp font_stfangso_ttf_25_4bpp_13.cpp font_stfangso_ttf_25_4bpp_14.cpp font_stfangso_ttf_25_4bpp_15.cpp font_stfangso_ttf_25_4bpp_16.cpp font_stfangso_ttf_25_4bpp_17.cpp font_stfangso_ttf_25_4bpp_18.cpp font_stfangso_ttf_25_4bpp_31.cpp font_stfangso_ttf_25_4bpp_6.cpp font_stfangso_ttf_25_4bpp_9.cpp font_stfangso_ttf_40_4bpp_0.cpp font_stkaiti_ttf_32_4bpp_0.cpp font_stkaiti_ttf_32_4bpp_10.cpp font_stkaiti_ttf_32_4bpp_11.cpp font_stkaiti_ttf_32_4bpp_12.cpp font_stkaiti_ttf_32_4bpp_13.cpp font_stkaiti_ttf_32_4bpp_14.cpp font_stkaiti_ttf_32_4bpp_15.cpp font_stkaiti_ttf_32_4bpp_9.cpp font_stxingka_ttf_25_4bpp_0.cpp font_stxingka_ttf_25_4bpp_10.cpp font_stxingka_ttf_25_4bpp_11.cpp font_stxingka_ttf_25_4bpp_12.cpp font_stxingka_ttf_25_4bpp_13.cpp font_stxingka_ttf_25_4bpp_14.cpp font_stxingka_ttf_25_4bpp_15.cpp font_stxingka_ttf_25_4bpp_16.cpp font_stxingka_ttf_25_4bpp_4.cpp font_stxingka_ttf_25_4bpp_9.cpp font_verdana_10_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_stfangso_ttf_25_4bpp.cpp kerning_stfangso_ttf_40_4bpp.cpp kerning_stkaiti_ttf_32_4bpp.cpp kerning_stxingka_ttf_25_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_stfangso_ttf_25_4bpp.cpp table_stfangso_ttf_40_4bpp.cpp table_stkaiti_ttf_32_4bpp.cpp table_stxingka_ttf_25_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp unmappeddatafont.cpp vectorfontrendererbuffers.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_about_80.cpp image_action_80.cpp image_air.cpp image_airplane.cpp image_back_64.cpp image_back_80.cpp image_blood_oxygen.cpp image_exclamation_mark.cpp image_exclamation_point.cpp image_forest.cpp image_fpv_80.cpp image_gps.cpp image_heart_rate.cpp image_humidity_64.cpp image_map_80.cpp image_p0704.cpp image_p07041.cpp image_plane.cpp image_sensor_80.cpp image_settings_80.cpp image_temperature_64.cpp image_warn.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/containers/: compass_1base.cpp compassbase.cpp customcontainer1base.cpp emergencybase.cpp trianglebase.cpp
    ../touchgfx/generated/gui_generated/src/fpv_menu_screen/: fpv_menuviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_normal.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_rounded_pressed.cpp image_glass_theme_images_widgets_circleprogress_backgrounds_medium.cpp image_icon_theme_images_action_done_50_50_e8f6fb.svg.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/main_menu_screen/: main_menuviewbase.cpp
    ../touchgfx/generated/gui_generated/src/map_menu_screen/: map_menuviewbase.cpp
    ../touchgfx/generated/gui_generated/src/sensor_menu_screen/: sensor_menuviewbase.cpp
    ../touchgfx/generated/gui_generated/src/set_menu_screen/: set_menuviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 6.1.0
